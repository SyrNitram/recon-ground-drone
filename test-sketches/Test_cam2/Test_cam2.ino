// Recon Ground Drone - adapted file
// Original code (c) 2022-2023 Martin RYS, released under the MIT License.
// Adapted from: un0038998 / CameraCarWithPanTiltControl (MIT) and robotzero.one (see THIRD_PARTY.md).

//L298N ON ESP32 CAM
//https://www.youtube.com/watch?v=tyY7AN132Xs
//https://www.youtube.com/watch?v=tyY7AN132Xs
//https://github.com/un0038998/CameraCarWithPanTiltControl
//https://github.com/un0038998/CameraCarWithPanTiltControl

//PWM
//https://electroniqueamateur.blogspot.com/2019/08/modulation-par-largeur-dimpulsion-pwm.html
//https://electroniqueamateur.blogspot.com/2019/08/modulation-par-largeur-dimpulsion-pwm.html
//https://gist.github.com/benpeoples/3aa57bffc0f26ede6623ca520f26628c

//WEBSERVER AND HTML
//https://robotzero.one/esp32-cam-rc-car/
//https://robotzero.one/esp32-cam-rc-car/
//https://robotzero.one/esp32-cam-rc-car/
//DECODE HTML : https://gchq.github.io/CyberChef/#recipe=Find_/_Replace(%7B'option':'Regex','string':','%7D,'',true,false,false,false)Remove_whitespace(true,false,true,false,false,false)From_Hex('0x')Gunzip()&input=MHgxZiwweDhiLDB4MDgsMHgwOCwweDIyLDB4MTYsMHgzYiwweDVkLDB4MDAsMHhmZiwweDY5LDB4NmUsMHg2NCwweDY1LDB4NzgsMHgyZSwweDY4LDB4NzQsMHg2ZCwweDZjLDB4MmUsMHg2NywweDdhLDB4MDAsMHg5NSwweDU4LDB4N2IsMHg4ZiwweGRiLDB4MzYsMHgxMiwweGZmLDB4N2IsMHhmZCwweDI5LDB4NTgsMHgwNywweDU3LDB4ZGIsMHgxNywweDViLDB4ZjIsMHhkYSwweDQ5LDB4MmYsMHg3MSwweGVjLDB4M2QsMHg1YywweGJhLDB4MDEsMHg1YSwweGEwLDB4NDUsMHg4MywweGRiLDB4YmQsMHgyNiwweGMxLDB4ZTEsMHhiMCwweGEwLDB4YTUsMHg5MSwweGNkLDB4NDQsMHgxMiwweDc1LDB4MjQsMHhlNSwweGM3LDB4NWQsMHhmNywweGJiLDB4NzcsMHg4NiwweGEyLDB4MjQsMHhjYSwweGViLDB4NWQsMHgyNCwweGZlLDB4YzMsMHg5NiwweGM4LDB4ZjksMHhjZCwweGYzLDB4YzEsMHhhMSwweDk3LDB4NWIsMHg5MywweGE1LDB4NTcsMHhiZCwweGU1LDB4MTYsMHg3OCwweDhjLDB4M2YsMHgxOSwweDE4LDB4Y2UsMHg3MiwweDllLDB4YzEsMHg2YSwweGIwLDB4MTMsMHhiMCwweDJmLDB4YTQsMHgzMiwweDAzLDB4NTYsMHg3ZiwweDIyLDB4OTksMHgxYiwweGM4LDB4Y2QsMHg2YSwweGIwLDB4MTcsMHhiMSwweGQ5LDB4YWUsMHg2MiwweGQ4LDB4ODksMHgwOCwweDI2LDB4ZjYsMHg2NSwweGRjLDB4MTAsMHg4OSwweDVjLDB4MTgsMHhjMSwweGQzLDB4ODksMHg4ZSwweDc4LDB4MGEsMHhhYiwweGNiLDB4NjAsMHhkYSwweDZlLDB4OTUsMHgxYSwweDk0LDB4NWQsMHhlNywweDZiLDB4ZGMsMHhjYSwweGU1LDB4ODAsMHg4NSwweDI4LDB4ZDIsMHgwOCwweDkzLDB4YzIsMHhkNSwweDdiLDB4OWUsMHgzMywweDllLDB4YzcsMHhlYywweDU2LDB4YTQsMHg4NiwweGJkLDB4YmIsMHg3OSwweDNmLDB4OWYsMHg0ZCwweDdlLDB4ZmMsMHhjNywweGFmLDB4Y2IsMHhiMCwweGRhLDB4ZWQsMHgyZCwweGI1LDB4MzksMHhlMiwweDJmLDB4ZWIsMHgzZCwweDIzLDB4MjUsMHhiOCwweGM4LDB4NDEsMHhiMSwweGZmLDB4ZjcsMHgyYywweDU3LDB4MmIsMHg3ZiwweGMxLDB4MmUsMHhhNywweGQzLDB4YmYsMHhiYywweGE5LDB4NTYsMHhiNiwweDIwLDB4MzYsMHg1YiwweGIzLDB4NjAsMHgyZiwweDVlLDB4ZWYsMHhiNiwweDZlLDB4NjksMHhjZCwweGEzLDB4MmYsMHgxYiwweDI1LDB4Y2IsMHgzYywweDllLDB4NDQsMHgzMiwweDk1LDB4NmEsMHhjMSwweDllLDB4Y2QsMHhlNywweDczLDB4YjcsMHgxOSwweDBiLDB4NWQsMHhhNCwweGZjLDB4YjgsMHg2MCwweDQ5LDB4MGEsMHgwNywweGI3LDB4YzYsMHg1MywweGIxLDB4YzksMHgyNywweGMyLDB4NDAsMHhhNiwweDE3LDB4MmMsMHg0MiwweGFiLDB4NDEsMHhiOSwweDlkLDB4Y2YsMHhhNSwweDM2LDB4MjIsMHgzOSwweDIyLDB4MWYsMHhlYiwweDhkLDB4OTMsMHg1ZCwweGI5LDB4MDMsMHg5NSwweGE0LDB4NzIsMHhiZiwweDYwLDB4NWIsMHgxMSwweGM3LDB4OTAsMHhkNywweGYyLDB4YTUsMHg4YSwweGQxLDB4NzgsMHhjNSwweDYzLDB4NTEsMHgyMiwweGMzLDB4YmYsMHgxNSwweGI1LDB4MWMsMHgyMywweGNiLDB4NjgsMHgzYiwweGUxLDB4OTEsMHgxMSwweDMyLDB4NWYsMHhiMCwweDVjLDB4ZTYsMHhmMCwweGE2LDB4NzcsMHhkZiwweDYzLDB4Y2YsMHg0OCwweGYyLDB4NDMsMHgwYiwweDFiLDB4NTgsMHg2ZCwweGEyLDB4YmYsMHhmNiwweGQwLDB4NDYsMHhiNSwweDU5LDB4MGYsMHg2NywweDJmLDB4NWUsMHg4ZSwweGQ5LDB4NmMsMHg4ZSwweDYxLDB4NzgsMHhmZCwweDdhLDB4ZDQsMHhkMSwweDg2LDB4ZDAsMHhjNSwweDgxLDB4NjksMHg5OSwweDhhLDB4OTgsMHg0OCwweGY5LDB4ZjAsMHg3MiwweGZlLDB4YzMsMHg5OCwweGI1LDB4NWYsMHhjMSwweGNiLDB4MmUsMHhhMCwweDUxLDB4ZmYsMHg2NSwweGUzLDB4ZWEsMHg3MywweGVhLDB4N2IsMHhiMSwweDg2LDB4MTQsMHgyMiwweGQ0LDB4YjIsMHg2YiwweGQ2LDB4ODIsMHhjOCwweDc3LDB4NTAsMHg1YiwweDc3LDB4NTYsMHg2ZCwweGQ0LDB4ZTUsMHg4NywweDU3LDB4YTgsMHhmNywweDI1LDB4N2QsMHhjZCwweDUwLDB4NzksMHg0YywweGE0LDB4MjksMHg2YSwweGQzLDB4ZjAsMHhkOCwweDkyLDB4YTMsMHg2YiwweDE2LDB4NTEsMHhhOSwweDM0LDB4MDEsMHgwYiwweDI5LDB4YmMsMHg1MCwweDM4LDB4YTUsMHg5ZCwweGY3LDB4NjYsMHhkNiwweDUxLDB4ODQsMHhlNywweDBhLDB4NzgsMHg4ZCwweDJjLDB4YTQsMHhjNiwweDc0LDB4MjUsMHhkZCwweDEzLDB4NzEsMHg4MCwweGQ4LDB4MjEsMHg1NSwweGU1LDB4ZGMsMHg2OSwweDYzLDB4NjQsMHg2MSwweDVmLDB4ZWUsMHg3YiwweGJkLDB4NDQsMHg2YywweDRhLDB4MDUsMHgwZSwweDdjLDB4MjYsMHhjZiwweDBhLDB4MWUsMHhjNywweDIyLDB4ZGYsMHgyYywweDZhLDB4NjgsMHhjNiwweGQ1LDB4NDYsMHhlNCwweGNkLDB4ZWIsMHg2NCwweDBmLDB4ZWIsMHgyZiwweGMyLDB4NGMsMHhhYSwweGU1LDB4YzksMHgxYSwweDEyLDB4YTksMHhlMCwweDg0LDB4NzgsMHhiMiwweDRlLDB4NjUsMHhmNCwweDY1LDB4YTIsMHgwZCwweDU3LDB4ZTYsMHgzMSwweDIwLDB4NGYsMHhkMCwweGNjLDB4ZjMsMHgzOCwweGM4LDB4ZTMsMHhjNywweDUwLDB4NWQsMHg5NiwweDZlLDB4NTEsMHhlNCwweDI5LDB4NTYsMHhkMywweGQzLDB4ZTIsMHg3YywweDllLDB4NWQsMHg5OCwweGRkLDB4NjEsMHhlOCwweDk5LDB4Y2EsMHgzMSwweDRjLDB4NjQsMHgxYiwweGU3LDB4OWMsMHhiYSwweGE4LDB4YWMsMHg1NiwweDBlLDB4NWIsMHg4NSwweDgyLDB4OTcsMHg0NiwweDc2LDB4ZDMsMHhkOCwweDJmLDB4ZDQsMHg0ZSwweGE2LDB4YmQsMHg2OCwweDkyLDB4ZGIsMHg4OSwweGE1LDB4NTAsMHhiYywweGMyLDB4YTQsMHhhNSwweDU4LDB4MmMsMHhjMywweGFhLDB4MjksMHhlMCwweDgzLDB4ZWIsMHg1ZSwweDZiLDB4MTksMHgxZiwweGYxLDB4NDcsMHhlNCwweDQ1LDB4NjksMHg5OCwweDM5LDB4MTYsMHhkOCwweGM1LDB4MGMsMHgxYywweGQwLDB4MzIsMHhlMCwweDAzLDB4MjYsMHhlMiwweGQ1LDB4YTAsMHg3YSwweDQyLDB4ZDUsMHhhOCwweDAzLDB4YzUsMHhiNiwweGZkLDB4YzQsMHg2MiwweDY3LDB4YjcsMHg2NCwweDg5LDB4MmUsMHhmZCwweGIxLDB4NmUsMHgyZSwweDgzLDB4MmIsMHgxNCwweGRiLDB4ZWMsMHgzNSwweDNkLDB4YzcsMHgyZSwweDdiLDB4MWIsMHg5NCwweDhhLDB4ODMsMHgyYiwweGI2LDB4MGMsMHg3MSwweGMxLDB4MjIsMHg5YSwweDA3LDB4ZTcsMHgwZiwweGFiLDB4ZTEsMHhhYSwweGVmLDB4ZDksMHhkOSwweGVmLDB4YjIsMHhlOCwweDZiLDB4ODMsMHgzYSwweDY1LDB4YjYsMHg5YiwweDU4LDB4MTEsMHg3ZCwweDE2LDB4YTUsMHg1YywweGViLDB4NTUsMHg1ZiwweDY0LDB4N2MsMHgwMywweGRlLDB4M2EsMHg4YSwweDQxLDB4ZWYsMHg3YSwweDk4LDB4M2UsMHhkMywweDJhLDB4NWEsMHhmNSwweDY5LDB4YTMsMHg5NSwweDVmLDB4YzksMHgyNSwweDlmLDB4ZDgsMHhhNSwweGE1LDB4OGUsMHg5NCwweDI4LDB4Y2MsMHg1NSwweDBmLDB4ZjksMHg2OCwweGMzLDB4YTgsMHhhNywweGIzLDB4MTUsMHg4YiwweDY1LDB4NTQsMHg2NiwweGQ4LDB4YjUsMHg4MiwweDBkLDB4OTgsMHg3NywweDI5LDB4ZDAsMHhlMywweGRiLDB4ZTMsMHhjZiwweGYxLDB4NzAsMHg1MCwweDMxLDB4MWUsMHg2MCwweGExLDB4NTUsMHhmNCwweDFmLDB4NmUsMHhlZSwweGZlLDB4ZjUsMHhjZiwweDVmLDB4MTAsMHhkMSwweGRmLDB4ZWIsMHg0NSwweDE4LDB4ZjYsMHhkOSwweDczLDB4OGMsMHg2MSwweDFlLDB4Y2IsMHg3ZCwweDgwLDB4NTEsMHhlNSwweDU0LDB4MzgsMHhjMSwweDU2LDB4MjIsMHhkZCwweDczLDB4ZDYsMHg1ZiwweGJjLDB4OWEsMHhmNSwweDZiLDB4ZDgsMHg1ZSwweDIzLDB4MjQsMHg0NywweDUxLDB4MWYsMHg2MCwweDdkLDB4ODMsMHhlMSwweDA3LDB4MzMsMHhhYywweDM4LDB4MjEsMHhlMywweDhiLDB4OGIsMHhkZSwweDVlLDB4MDcsMHgzMiwweGNmLDB4NDAsMHg2YiwweDM0LDB4MTAsMHgwOSwweDliLDB4YTcsMHgyYiwweGFjLDB4Y2EsMHgwYiwweDkxLDB4YjAsMHhhMSwweDViLDB4MDksMHg2MiwweDhlLDB4YTcsMHg5MSwweDQwLDB4OGUsMHgzYywweDhmLDB4NDAsMHgyNiwweGVjLDB4NmQsMHgyYSwweGQ3LDB4MjMsMHgyMiwweDYyLDB4NmMsMHhjNywweDE1LDB4MmIsMHg1NSwweGZhLDB4ZGIsMHhmYSwweDMzLDB4NzYsMHgxOCwweDY0LDB4ODIsMHhjYywweDgzLDB4MDgsMHg5NSwweDM3LDB4NTAsMHgyZCwweGUxLDB4N2IsMHg4NywweDBkLDB4NDksMHg0NiwweDE0LDB4ZGEsMHgxZiwweGEwLDB4ZDcsMHgxMCwweGQwLDB4ODAsMHg3MSwweGUzLDB4YmUsMHg3NywweGZmLDB4YTYsMHhkNywweDIzLDB4OTYsMHhiMSwweGUyLDB4OWIsMHg5ZiwweGE5LDB4ZjUsMHg3YSwweDRlLDB4ZmEsMHg2ZiwweDA5LDB4ZWEsMHg3OCwweDYzLDB4NWIsMHg5OSwweDU0LDB4YzMsMHg4MSwweGVkLDB4M2YsMHhlNCwweDIyLDB4YTIsMHg2ZiwweDRmLDB4YTMsMHgyNywweDAwLDB4NmQsMHhmYSwweDljLDB4YTIsMHgzZSwweDUwLDB4NDEsMHgyMCwweGI0LDB4NTksMHgwOCwweDY0LDB4OTIsMHg2OCwweDMwLDB4NzYsMHhmZCwweDg0LDB4ZjYsMHgyNywweDliLDB4NDMsMHg2NywweDg4LDB4YWIsMHg4ZCwweDhhLDB4M2EsMHhlMywweDg3LDB4NmIsMHgzNCwweGUxLDB4MjcsMHhhOSwweGM0LDB4ZmYsMHg4OCwweDJjLDB4ZjUsMHhlOSwweDJiLDB4NjksMHgyMSwweDliLDB4NzUsMHg2OCwweDdmLDB4MDcsMHg2NSwweDA0LDB4MWUsMHhjYSwweDNlLDB4YTUsMHg5MywweDY1LDB4NDksMHgxZiwweDRkLDB4MTYsMHg1YiwweDRjLDB4YTMsMHg2MCwweGM3LDB4ZDMsMHg5MiwweGMyLDB4NTgsMHg0ZCwweDA1LDB4MGIsMHgzNiwweGMwLDB4NmMsMHg3OCwweGE4LDB4YzYsMHg3MywweDVjLDB4YWYsMHhmYiwweGE1LDB4NDcsMHg1MSwweDBiLDB4YWYsMHgzNCwweDcyLDB4MDcsMHhjMywweDhhLDB4MjUsMHgzYywweGQ1LDB4NzgsMHg2MiwweDU4LDB4ZmIsMHg0YiwweGE1LDB4NTAsMHhlNCwweGM3LDB4Y2UsMHhkYiwweGE3LDB4ZWEsMHhjZCwweGNkLDB4MWEsMHg2ZSwweGNmLDB4YmQsMHhiOSwweGJkLDB4YzMsMHg2ZiwweGQ2LDB4MzksMHhjOCwweDBjLDB4M2IsMHgxNywweDJkLDB4MWMsMHg0ZiwweDE3LDB4YjAsMHhjYywweGNjLDB4MmQsMHhiNiwweDg3LDB4YjEsMHg3ZCwweGJhLDB4YzEsMHg1NiwweDM2LDB4NjYsMHgxYSwweGJmLDB4NmYsMHg0NSwweDA2LDB4ZDgsMHgwZCwweDZjLDB4MzIsMHgzYiwweDQ3LDB4NjMsMHg1NywweDdmLDB4YjcsMHg0MywweGI5LDB4YmYsMHgwOCwweDhkLDB4NjcsMHgzZSwweDYwLDB4NTAsMHhlZCwweGMxLDB4NjcsMHg5YiwweGU2LDB4NjAsMHg2YywweGIzLDB4ZTYsMHg4NiwweDllLDB4YzcsMHg5NSwweGU2LDB4NTUsMHhmZCwweDNjLDB4OGQsMHg0NSwweDQxLDB4MGUsMHhmOSwweDhlLDB4MDQsMHg3ZiwweDM1LDB4MmUsMHhjMywweDgzLDB4Y2YsMHgwMSwweGJmLDB4MGUsMHg5NSwweDQ5LDB4M2MsMHg4YiwweGIxLDB4NjQsMHhmMywweDZmLDB4NTcsMHhkNCwweDQyLDB4Y2IsMHhlMiwweDViLDB4ZjUsMHhiNCwweGIwLDB4YjMsMHg3YSwweGY2LDB4OTIsMHgzMiwweGI3LDB4YjMsMHg0MiwweGFiLDB4YzksMHgxMCwweGE4LDB4YTIsMHhlZCwweGU0LDB4ODgsMHg5NSwweDBmLDB4MDEsMHhiNSwweDZkLDB4YjYsMHg1YSwweDYxLDB4M2UsMHg3OSwweDJlLDB4YWUsMHg0OSwweGJjLDB4MDEsMHhmMywweDIzLDB4MDYsMHgxMiwweGE5LDB4YWQsMHgyYiwweGY1LDB4YmYsMHhhNywweGZmLDB4MDksMHhhMiwweDU0LDB4NTAsMHg5ZSwweGIwLDB4NDksMHgxZCwweDdhLDB4NzcsMHg3MiwweGI0LDB4OTAsMHg0ZiwweGU3LDB4MjEsMHg5ZiwweDEwLDB4ZTIsMHg5MiwweGEzLDB4ODIsMHhkYywweDMzLDB4NDAsMHg3NSwweDFmLDB4MTMsMHhmOSwweGI1LDB4NzIsMHgxZSwweDYzLDB4ZWUsMHhkYiwweDhhLDB4ODcsMHgxYSwweDY1LDB4MjQsMHg1YSwweDViLDB4MzcsMHgxZSwweGRmLDB4ZDIsMHhhNiwweDFjLDB4OGMsMHgyYSwweGRkLDB4NWMsMHg4NSwweDlkLDB4ZWEsMHhjNCwweDg5LDB4MTgsMHgxNSwweGNmLDB4ODUsMHhhZCwweGEyLDB4NmQsMHhkZCwweDljLDB4NjgsMHhkNiwweDk2LDB4NTAsMHg0NywweDg2LDB4MmIsMHhiOSwweDUzLDB4ZjYsMHhkZCwweGYwLDB4NTQsMHhkNCwweGJlLDB4OGUsMHgxMCwweDE0LDB4MGEsMHgyOCwweGZjLDB4ZDcsMHg5MCwweGYwLDB4MzIsMHgzNSwweGMzLDB4N2EsMHg2NCwweDdjLDB4MmMsMHhhMCwweDM2LDB4MmYsMHg3YywweDBlLDB4NmUsMHg4MCwweGIzLDB4Y2EsMHgzZSwweDFlLDB4ZDMsMHhiNiwweGQ0LDB4Y2YsMHhlMCwweDllLDB4MDgsMHg2YywweGRiLDB4MTQsMHg2YSwweGNjLDB4ODMsMHhlOCwweDNlLDB4NTAsMHhlMCwweDliLDB4YTQsMHgzZSwweDI5LDB4YWEsMHg3OSwweDZhLDB4YmIsMHg1MSwweDM3LDB4MmUsMHhmNCwweDY5LDB4MWIsMHg1MywweDM3LDB4MzQsMHhiNSwweDBiLDB4N2YsMHhlNSwweDY2LDB4MWIsMHhmMCwweGI1LDB4MWUsMHhkNiwweGRiLDB4MjMsMHhiNiwweDdjLDB4ZDAsMHhiYywweGJmLDB4ZmYsMHg5ZSwweDlkLDB4ZDIsMHg3ZCwweGY0LDB4ZTgsMHhkYSwweDRlLDB4N2MsMHhlYSwweDdhLDB4OTQsMHg3YywweGFiLDB4NzgsMHhhZSwweDUzLDB4M2MsMHgzYSwweDFiLDB4ZTQsMHhiOCwweDUxLDB4YTUsMHhhYSwweDYwLDB4OWIsMHg5OSwweGU3LDB4ZWMsMHhmYSwweGVhLDB4YzMsMHhlMSwweDYzLDB4ZDUsMHhmNiwweDFiLDB4M2YsMHhkMywweDc5LDB4ZjAsMHhhOSwweGIzLDB4ZTYsMHhhYywweGI2LDB4MTksMHgxZSwweDg2LDB4MmMsMHgxNSwweDk5LDB4MzAsMHhiNiwweDFmLDB4ZTMsMHgzYywweDhkLDB4MjMsMHgzOCwweGMzLDB4M2IsMHg0NCwweDMzLDB4MmEsMHg2MCwweGM2LDB4YTksMHgyMywweDliLDB4NGYsMHg1OSwweGE2LDB4ODksMHg3NiwweDZiLDB4NGMsMHg0MSwweGYzLDB4YzksMHg0NiwweDk4LDB4NmQsMHhiOSwweDBlLDB4MjIsMHg5OSwweDg1LDB4MzksMHhjOCwweDVjLDB4NjAsMHgxZiwweDBhLDB4ZjEsMHgyZSwweGY2LDB4NTksMHhkZiwweDgxLDB4MmUsMHhlNiwweGIzLDB4M2IsMHgzOCwweGYwLDB4YWMsMHg0OCwweDQxLDB4ODcsMHgzOCwweDk0LDB4YWUsMHhjMywweDBjLDB4YmIsMHgzZSwweGE4LDB4ODYsMHhmMiwweDBlLDB4MDUsMHg4NCwweDExLDB4YTQsMHg2OSwweGIxLDB4YzUsMHhhNywweDNiLDB4NmEsMHg3MCwweDRhLDB4YTYsMHgzOCwweDI2LDB4ZGUsMHhhOSwweGU4LDB4MmUsMHhlMiwweDJhLDB4ZGMsMHhlZiwweGY3LDB4MjEsMHgwZSwweDNmLDB4NzAsMHgwOCwweGU4LDB4Y2UsMHhkYywweDk2LDB4MDksMHhlOSwweDM4LDB4MzQsMHgwNywweDUzLDB4N2IsMHg5NiwweGNlLDB4OTYsMHg1YywweGQyLDB4OWMsMHg0NSwweDIzLDB4ZDAsMHgzNSwweGY5LDB4NzUsMHg0NCwweGZlLDB4YTEsMHg3MywweGE1LDB4MmUsMHgwZiwweDkxLDB4MGMsMHhlYiwweDQzLDB4YzcsMHhkNiwweDA2LDB4ZGUsMHg3ZSwweDIwLDB4YzEsMHg3NiwweDFhLDB4YjMsMHgzZiwweGZlLDB4YjAsMHhlMCwweDQ5LDB4NzMsMHgyOCwweGIxLDB4YWIsMHgxNSwweDVhLDB4ZWEsMHg4NywweGNkLDB4YTAsMHhlZCwweGRkLDB4MjAsMHhlMiwweDQ0LDB4ZDUsMHg2OCwweGQxLDB4Y2QsMHhkNSwweDU2LDB4Y2EsMHgxMywweGRhLDB4ZDQsMHgxZiwweDA1LDB4YTYsMHg1NCwweGY1LDB4OTUsMHhkNSwweDk2LDB4MGEsMHgwZSwweDc5LDB4ZDEsMHhiNiwweGVkLDB4MDEsMHhkZSwweDNmLDB4MDEsMHg3OCwweDZkLDB4MDQsMHg5YywweDAyLDB4YTksMHg0MSwweDljLDB4MjYsMHg0NiwweGY1LDB4NWQsMHgxZiwweGFmLDB4ZDQsMHhiZiwweDBlLDB4YWUsMHhmOSwweGExLDB4ZDksMHhkZiwweDc5LDB4NDcsMHhhYywweGNmLDB4ZDYsMHg0ZSwweDI0LDB4MzQsMHgzNywweDM2LDB4MWEsMHg3ZiwweGQ3LDB4ZjEsMHhjYiwweGRmLDB4MjksMHhkYywweDEzLDB4MzYsMHhlYywweDNhLDB4NjcsMHhjNCwweDE2LDB4YjgsMHhlZSwweGQ3LDB4Y2IsMHgxMCwweDk5LDB4MmMsMHhkOSwweDc0LDB4ZDQsMHhkMSwweGQ3LDB4MzIsMHhmNiwweGM4LDB4M2MsMHgxZCwweDcwLDB4ODMsMHg0YSwweGEwLDB4N2EsMHgxOSwweDBlLDB4NDcsMHhkNSwweDE4LDB4ZGEsMHhhZCwweDEwLDB4OWYsMHgzOCwweDJmLDB4NTMsMHg5YywweDU2LDB4NGUsMHhmNywweDZkLDB4MzQsMHhjOSwweDVhLDB4ZGYsMHgxOSwweDYzLDB4OTQsMHhlYiwweGRlLDB4YmIsMHg3ZCwweGJiLDB4NTMsMHg3MywweDg3LDB4ZjcsMHg1MiwweDhmLDB4ZDksMHhkMSwweDdlLDB4NDMsMHg1MywweDllLDB4OTAsMHgwNiwweGY2LDB4ZWUsMHgxMCwweDE4LDB4MjIsMHhjNCwweDZiLDB4MjIsMHg4ZCwweGE0LDB4MDMsMHhmYiwweDQyLDB4YTgsMHgzOSwweDk2LDB4MTgsMHg5NiwweDBlLDB4NjEsMHhhOSwweDk0LDB4OGEsMHhjMywweGQ4LDB4OTYsMHgxMiwweDcxLDB4YTksMHhkZiwweGE3LDB4YTMsMHg0MSwweDI1LDB4OWIsMHgzYywweDViLDB4ZjAsMHhmYywweDFhLDB4MzYsMHgwYSwweDgwLDB4MWMsMHg2MSwweDUxLDB4N2YsMHg2NSwweGFmLDB4YTcsMHgzOCwweGUwLDB4M2QsMHhlOCwweDBmLDB4MmQsMHhjNiwweGUwLDB4NWYsMHgzMSwweDJkLDB4YzgsMHhiMiwweGVlLDB4ODIsMHhkYSwweGUxLDB4ZWQsMHhjMiwweGZhLDB4YzAsMHgxMywweDgyLDB4M2EsMHg4YywweDQ5LDB4MjEsMHg4ZiwweDg3LDB4YmQsMHhiZCwweGUzLDB4OWQsMHhjZCwweDVkLDB4NDgsMHg5NiwweGExLDB4YmIsMHhhZCwweDg1LDB4ZjYsMHgxZiwweGE4LDB4M2YsMHgwMSwweDY5LDB4YjYsMHg3YSwweGIwLDB4ODgsMHgxMiwweDAwLDB4MDAK
//ENCODE HTML : https://gchq.github.io/CyberChef/#recipe=Gzip('Dynamic%20Huffman%20Coding','index.html.gz','',false)To_Hex('0x',0)Split('0x',',0x')&input=PGh0bWw%2BCjxoZWFkPgo8bWV0YSBuYW1lPSd2aWV3cG9ydCcgICAgICAgICBjb250ZW50PSd3aWR0aD1kZXZpY2Utd2lkdGgsICAgICAgICAgaW5pdGlhbC1zY2FsZT0xLjAsICAgICAgICAgdXNlci1zY2FsYWJsZT1ubycgLz4KPHRpdGxlPlBhbiBhbmQgVGlsdCBFU1AzMi1DQU08L3RpdGxlPgo8c3R5bGU%2BIAojY29udGFpbmVyIHsKICAgICB3aWR0aDogMTAwJTsKICAgICBoZWlnaHQ6IDQ5dmg7CiAgICAgYmFja2dyb3VuZC1jb2xvcjogIzMzMzsKICAgICBkaXNwbGF5OiBmbGV4OwogICAgIGFsaWduLWl0ZW1zOiBjZW50ZXI7CiAgICAganVzdGlmeS1jb250ZW50OiBjZW50ZXI7CiAgICAgb3ZlcmZsb3c6IGhpZGRlbjsKICAgICBib3JkZXItcmFkaXVzOiA3cHg7CiAgICAgdG91Y2gtYWN0aW9uOiBub25lOwp9CiAjaXRlbSB7CiAgICAgd2lkdGg6IDEwMHB4OwogICAgIGhlaWdodDogMTAwcHg7CiAgICAgYmFja2dyb3VuZC1jb2xvcjogcmdiKDI0NSwgMjMwLCA5OSk7CiAgICAgYm9yZGVyOiAxMHB4IHNvbGlkIHJnYmEoMTM2LCAxMzYsIDEzNiwgLjUpOwogICAgIGJvcmRlci1yYWRpdXM6IDUwJTsKICAgICB0b3VjaC1hY3Rpb246IG5vbmU7CiAgICAgdXNlci1zZWxlY3Q6IG5vbmU7Cn0KICNpdGVtOmFjdGl2ZSB7CiAgICAgYmFja2dyb3VuZC1jb2xvcjogcmdiYSgxNjgsIDIxOCwgMjIwLCAxLjAwKTsKfQogI2l0ZW06aG92ZXIgewogICAgIGN1cnNvcjogcG9pbnRlcjsKICAgICBib3JkZXItd2lkdGg6IDIwcHg7Cn0KICNhcmVhIHsKICAgICBwb3NpdGlvbjogZml4ZWQ7CiAgICAgcmlnaHQ6IDA7CiAgICAgdG9wOiAwOwp9CgpmaWd1cmV7CiAgICAgaGVpZ2h0OiA0OXZoOwogICAgIHBhZGRpbmc6MDsKICAgICBtYXJnaW46MDsKICAgICAtd2Via2l0LW1hcmdpbi1iZWZvcmU6MDsKICAgICBtYXJnaW4tYmxvY2stc3RhcnQ6MDsKICAgICAtd2Via2l0LW1hcmdpbi1hZnRlcjowOwogICAgIG1hcmdpbi1ibG9jay1lbmQ6MDsKICAgICAtd2Via2l0LW1hcmdpbi1zdGFydDowOwogICAgIG1hcmdpbi1pbmxpbmUtc3RhcnQ6MDsKICAgICAtd2Via2l0LW1hcmdpbi1lbmQ6MDsKICAgICBtYXJnaW4taW5saW5lLWVuZDowIAp9CmZpZ3VyZSBpbWd7CiAgICAgZGlzcGxheTpibG9jazsKICAgICB3aWR0aDphdXRvOwogICAgIGhlaWdodDo0OXZoOwogICAgIGJvcmRlci1yYWRpdXM6NHB4OwogICAgIG1hcmdpbi10b3A6OHB4IAp9Cgo8L3N0eWxlPgo8L2hlYWQ%2BCjxib2R5Pgo8aW5wdXQgdHlwZT0ndGV4dGFyZWEnIGlkPSdhcmVhJyBkaXNhYmxlZCAvPgo8ZGl2IGlkPSdvdXRlckNvbnRhaW5lcic%2BCiAgPGRpdiBpZD0nY29udGFpbmVyJz4KICAgIDxkaXYgaWQ9J2l0ZW0nPiA8L2Rpdj4KICA8L2Rpdj4KICA8ZmlndXJlIHN0eWxlPSJoZWlnaHQ6NDl2aCI%2BCiAgICA8ZGl2IGlkPSJzdHJlYW0tY29udGFpbmVyIiBjbGFzcz0iaW1hZ2UtY29udGFpbmVyIj4gPGltZyBpZD0ic3RyZWFtIiBzcmM9IiI%2BIDwvZGl2PgogIDwvZmlndXJlPgo8L2Rpdj4KPHNjcmlwdD4KY29uc3QgdmlldyA9IGRvY3VtZW50LmdldEVsZW1lbnRCeUlkKCdzdHJlYW0nKTsKY29uc3QgV1NfVVJMID0gIndzOi8vIiArIHdpbmRvdy5sb2NhdGlvbi5ob3N0ICsgIjo4MiI7CmNvbnN0IHdzID0gbmV3IFdlYlNvY2tldChXU19VUkwpOwoJCQp3cy5vbm1lc3NhZ2UgPSBtZXNzYWdlID0%2BIHsKCWlmIChtZXNzYWdlLmRhdGEgaW5zdGFuY2VvZiBCbG9iKSB7CgkgIHZhciB1cmxPYmplY3QgPSBVUkwuY3JlYXRlT2JqZWN0VVJMKG1lc3NhZ2UuZGF0YSk7CgkgIHZpZXcuc3JjID0gdXJsT2JqZWN0OwoJfQp9OwoKdmFyIGRyYWdJdGVtID0gZG9jdW1lbnQucXVlcnlTZWxlY3RvcignI2l0ZW0nKTsKdmFyIGNvbnRhaW5lciA9IGRvY3VtZW50LnF1ZXJ5U2VsZWN0b3IoJyNjb250YWluZXInKTsKdmFyIGNvbnRhaW5lcldpZHRoID0gY29udGFpbmVyLm9mZnNldFdpZHRoOwp2YXIgY29udGFpbmVySGVpZ2h0ID0gY29udGFpbmVyLm9mZnNldEhlaWdodDsKdmFyIG1heERyYWdIb3Jpem9udGFsID0gY29udGFpbmVyV2lkdGggLyAyOwp2YXIgbWF4RHJhZ1ZlcnRpY2FsID0gY29udGFpbmVySGVpZ2h0IC8gMjsKZG9jdW1lbnQuZ2V0RWxlbWVudEJ5SWQoJ2FyZWEnKS52YWx1ZSA9ICd3aWR0aDogJyArIG1heERyYWdIb3Jpem9udGFsICsgJyBoZWlnaHQ6ICcgKyBtYXhEcmFnVmVydGljYWw7CnZhciBhY3RpdmUgPSBmYWxzZTsKdmFyIGN1cnJlbnRYOwp2YXIgY3VycmVudFk7CnZhciBpbml0aWFsWDsKdmFyIGluaXRpYWxZOwp2YXIgeE9mZnNldCA9IDA7CnZhciB5T2Zmc2V0ID0gMDsKdmFyIGxhc3RUZXh0LCBsYXN0U2VuZCwgc2VuZFRpbWVvdXQ7CmNvbnRhaW5lci5hZGRFdmVudExpc3RlbmVyKCd0b3VjaHN0YXJ0JywgZHJhZ1N0YXJ0LCBmYWxzZSk7CmNvbnRhaW5lci5hZGRFdmVudExpc3RlbmVyKCd0b3VjaGVuZCcsIGRyYWdFbmQsIGZhbHNlKTsKY29udGFpbmVyLmFkZEV2ZW50TGlzdGVuZXIoJ3RvdWNobW92ZScsIGRyYWcsIGZhbHNlKTsKY29udGFpbmVyLmFkZEV2ZW50TGlzdGVuZXIoJ21vdXNlZG93bicsIGRyYWdTdGFydCwgZmFsc2UpOwpjb250YWluZXIuYWRkRXZlbnRMaXN0ZW5lcignbW91c2V1cCcsIGRyYWdFbmQsIGZhbHNlKTsKY29udGFpbmVyLmFkZEV2ZW50TGlzdGVuZXIoJ21vdXNlbW92ZScsIGRyYWcsIGZhbHNlKTsKCmZ1bmN0aW9uIGRyYWdTdGFydChlKSB7CiAgICBpZiAoZS50eXBlID09PSAndG91Y2hzdGFydCcpIHsKICAgICAgICBpbml0aWFsWCA9IGUudG91Y2hlc1swXS5jbGllbnRYIC0geE9mZnNldDsKICAgICAgICBpbml0aWFsWSA9IGUudG91Y2hlc1swXS5jbGllbnRZIC0geU9mZnNldDsKICAgIH0gZWxzZSB7CiAgICAgICAgaW5pdGlhbFggPSBlLmNsaWVudFggLSB4T2Zmc2V0OwogICAgICAgIGluaXRpYWxZID0gZS5jbGllbnRZIC0geU9mZnNldDsKICAgIH0KICAgIGlmIChlLnRhcmdldCA9PT0gZHJhZ0l0ZW0pIHsKICAgICAgICBhY3RpdmUgPSB0cnVlOwogICAgfQp9CgpmdW5jdGlvbiBkcmFnRW5kKGUpIHsKICAgIGluaXRpYWxYID0gY3VycmVudFg7CiAgICBpbml0aWFsWSA9IGN1cnJlbnRZOwogICAgYWN0aXZlID0gZmFsc2U7Cn0KCmZ1bmN0aW9uIGRyYWcoZSkgewogICAgaWYgKGFjdGl2ZSkgewogICAgICAgIGUucHJldmVudERlZmF1bHQoKTsKICAgICAgICBpZiAoZS50eXBlID09PSAndG91Y2htb3ZlJykgewogICAgICAgICAgICBjdXJyZW50WCA9IGUudG91Y2hlc1swXS5jbGllbnRYIC0gaW5pdGlhbFg7CiAgICAgICAgICAgIGN1cnJlbnRZID0gZS50b3VjaGVzWzBdLmNsaWVudFkgLSBpbml0aWFsWTsKICAgICAgICB9IGVsc2UgewogICAgICAgICAgICBjdXJyZW50WCA9IGUuY2xpZW50WCAtIGluaXRpYWxYOwogICAgICAgICAgICBjdXJyZW50WSA9IGUuY2xpZW50WSAtIGluaXRpYWxZOwogICAgICAgIH0KICAgICAgICB4T2Zmc2V0ID0gY3VycmVudFg7CiAgICAgICAgeU9mZnNldCA9IGN1cnJlbnRZOwogICAgICAgIGlmIChNYXRoLmFicyhjdXJyZW50WSkgPCBtYXhEcmFnVmVydGljYWwgJiYgTWF0aC5hYnMoY3VycmVudFgpIDwgbWF4RHJhZ0hvcml6b250YWwpIHsKICAgICAgICAgICAgc2V0VHJhbnNsYXRlKGN1cnJlbnRYLCBjdXJyZW50WSwgZHJhZ0l0ZW0pOwogICAgICAgIH0KICAgICAgICBkb2N1bWVudC5nZXRFbGVtZW50QnlJZCgnYXJlYScpLnZhbHVlID0gJ1g6ICcgKyBjdXJyZW50WCArICcgWTogJyArIGN1cnJlbnRZOwogICAgfQp9CgovLyBsaW1pdCBzZW5kaW5nIHRvIG9uZSBtZXNzYWdlIGV2ZXJ5IDMwIG1zCi8vIGh0dHBzOi8vZ2l0aHViLmNvbS9uZW9uaW91cy9sb3dqc19lc3AzMl9leGFtcGxlcy9ibG9iL21hc3Rlci9uZW9uaW91c19vbmUvY2VsbHBob25lX2NvbnRyb2xsZWRfcmNfY2FyL3d3dy9pbmRleC5odG1sCmZ1bmN0aW9uIHNlbmQodHh0KSB7CiAgICB2YXIgbm93ID0gbmV3IERhdGUoKS5nZXRUaW1lKCk7CiAgICBpZihsYXN0U2VuZCA9PT0gdW5kZWZpbmVkIHx8IG5vdyAtIGxhc3RTZW5kID49IDMwKSB7CiAgICAgICAgdHJ5IHsKICAgICAgICAgICAgd3Muc2VuZCh0eHQpOwogICAgICAgICAgICBsYXN0U2VuZCA9IG5ldyBEYXRlKCkuZ2V0VGltZSgpOwogICAgICAgICAgICByZXR1cm47CiAgICAgICAgfSBjYXRjaChlKSB7CiAgICAgICAgICAgIGNvbnNvbGUubG9nKGUpOwogICAgICAgIH0KICAgIH0KICAgIGxhc3RUZXh0ID0gdHh0OwogICAgaWYoIXNlbmRUaW1lb3V0KSB7CiAgICAgICAgdmFyIG1zID0gbGFzdFNlbmQgIT09IHVuZGVmaW5lZCA/IDMwIC0gKG5vdyAtIGxhc3RTZW5kKSA6IDMwOwogICAgICAgIGlmKG1zIDwgMCkKICAgICAgICAgICAgbXMgPSAwOwogICAgICAgIHNlbmRUaW1lb3V0ID0gc2V0VGltZW91dCgoKSA9PiB7CiAgICAgICAgICAgIHNlbmRUaW1lb3V0ID0gbnVsbDsKICAgICAgICAgICAgc2VuZChsYXN0VGV4dCk7CiAgICAgICAgfSwgbXMpOwogICAgfQp9CgpmdW5jdGlvbiBzZXRUcmFuc2xhdGUoeFBvcywgeVBvcywgZWwpIHsKICAgIGVsLnN0eWxlLnRyYW5zZm9ybSA9ICd0cmFuc2xhdGUzZCgnICsgeFBvcyArICdweCwgJyArIHlQb3MgKyAncHgsIDApJzsKICAgIHZhciBwYW5EZWdyZWVzID0geFBvcyAqIDkwIC8gbWF4RHJhZ0hvcml6b250YWw7CiAgICB2YXIgdGlsdERlZ3JlZXMgPSB5UG9zICogOTAgLyBtYXhEcmFnVmVydGljYWw7CglzZW5kKHBhbkRlZ3JlZXMgKyAnLCcgKyB0aWx0RGVncmVlcyk7Cn0KPC9zY3JpcHQ%2BCjwvYm9keT4KPC9odG1sPg

#include <ArduinoWebsockets.h>
#include <WiFi.h>
#include <ESPAsyncWebServer.h>
#include "esp_camera.h"
 
const char* ssid = "YOUR_WIFI_SSID"; //Enter SSID
const char* password = "YOUR_WIFI_PASSWORD"; //Enter Password
 
const uint8_t index_html_gz[] = {0x1f,0x8b,0x08,0x08,0xf0,0xcc,0x47,0x63,0x00,0xff,0x69,0x6e,0x64,0x65,0x78,0x2e,0x68,0x74,0x6d,0x6c,0x2e,0x67,0x7a,0x00,0x9d,0x58,0x6d,0x6f,0xdb,0x38,0x12,0xfe,0xde,0x5f,0xc1,0xd5,0xe2,0x00,0xfb,0xd6,0x96,0x1c,0xa7,0xe9,0x35,0x3e,0xcb,0x05,0x7a,0x29,0xb0,0x01,0x5a,0xec,0x61,0x93,0xdb,0x36,0x38,0x1c,0x0c,0x5a,0xa2,0x6d,0xb6,0x94,0xa8,0x23,0x29,0xbf,0xdc,0xb5,0xff,0x7d,0x87,0x94,0x44,0x91,0xb2,0x9c,0x20,0xf1,0x07,0x83,0x1a,0x72,0x9e,0x19,0x0e,0xe7,0x8d,0x9c,0x6f,0x55,0xc6,0x16,0xaf,0x10,0x9a,0x6f,0x09,0x4e,0xf5,0x00,0x86,0x19,0x51,0xd8,0x8c,0x10,0xca,0x71,0x46,0xe2,0x60,0x47,0xc9,0xbe,0xe0,0x42,0x05,0x35,0x35,0xe1,0xb9,0x22,0xb9,0x8a,0x83,0x3d,0x4d,0xd5,0x36,0x4e,0xc9,0x8e,0x26,0x64,0x6c,0x3e,0x46,0xd5,0x0a,0xf8,0xd1,0x9c,0x2a,0x8a,0xd9,0x58,0x26,0x98,0x91,0xf8,0x22,0x9c,0xb4,0x53,0xa5,0x24,0xc2,0xd0,0xf1,0x0a,0xa6,0x72,0x5e,0xe1,0x46,0xb5,0x78,0x45,0x15,0x23,0x8b,0xdf,0xdf,0x8c,0x6f,0x04,0xcf,0x09,0xfa,0x07,0x08,0x13,0x9c,0x31,0x22,0xe6,0x51,0x35,0x55,0x2d,0x93,0xea,0xd8,0x8c,0x11,0xfa,0x59,0xab,0x84,0x69,0x4e,0x04,0xfa,0x7f,0x4d,0x42,0x28,0xc3,0x62,0x43,0xf3,0x19,0xc2,0xa5,0xe2,0x7f,0xb7,0xd4,0x94,0xca,0x82,0xe1,0xe3,0x0c,0xad,0x18,0x4f,0xbe,0xb5,0x74,0xa3,0xfe,0x0c,0x5d,0x4f,0xfe,0xd2,0xd2,0xb6,0x84,0x6e,0xb6,0x6a,0x86,0x5e,0x4f,0x76,0xdb,0x96,0xba,0xc2,0xc9,0xb7,0x8d,0xe0,0x65,0x9e,0x8e,0x13,0xce,0xb8,0x98,0xa1,0x9f,0x2f,0x2f,0x2f,0x7b,0x24,0xac,0x19,0x39,0xb4,0x64,0xcc,0xe8,0x26,0x1f,0x53,0x45,0x32,0x39,0x43,0x09,0xd8,0x8f,0x88,0x76,0xf2,0x6b,0x29,0x15,0x5d,0x1f,0x01,0xd0,0x98,0xf6,0x74,0x01,0xdf,0x11,0xb1,0x66,0x7c,0x3f,0x43,0x5b,0x9a,0xa6,0x24,0x77,0xd4,0xe1,0x22,0x05,0x7b,0x0a,0x9c,0xd2,0x12,0x90,0xff,0x56,0x38,0x32,0x15,0x2f,0x93,0xed,0x18,0x27,0x8a,0x72,0x30,0x44,0x0e,0xf6,0x6c,0xe6,0x7e,0x34,0x96,0xd3,0x0a,0x39,0x46,0xab,0xcd,0x70,0x31,0x99,0xb8,0x38,0x8d,0x21,0x3a,0xe4,0x53,0x4b,0x88,0xcd,0x6a,0x30,0x7d,0x7d,0x35,0x42,0xd3,0x4b,0x38,0xf0,0xeb,0xeb,0x61,0x57,0x4f,0x8d,0x51,0x1c,0x90,0xe4,0x8c,0xa6,0x7a,0x35,0x1e,0x5c,0x5c,0xbe,0x19,0xa1,0xf6,0x6f,0x12,0x5e,0x9d,0x30,0xd9,0xcd,0x5d,0xb9,0xa7,0x73,0x7e,0x73,0x8d,0x8b,0x11,0x46,0x12,0xd0,0xfa,0xec,0xbe,0x67,0x9a,0x79,0x47,0x9c,0xed,0xf7,0xee,0x08,0x74,0x7c,0xf3,0x16,0xb6,0x74,0xa1,0xff,0xa6,0xb0,0xaf,0x0b,0xab,0xa1,0x0f,0xb7,0xd5,0xa7,0xe4,0xa0,0x25,0xa5,0x90,0x1a,0xa3,0xe0,0xd4,0x3f,0xcd,0x7a,0x5b,0xb5,0xb1,0xa7,0x8e,0x51,0x2d,0x20,0x16,0x04,0x3b,0x50,0x05,0x97,0x10,0x4f,0x7a,0xa3,0x6b,0x7a,0x20,0x69,0x0b,0x25,0xaa,0x93,0x99,0xb8,0x76,0x29,0x9c,0xef,0x1f,0xaf,0x1a,0x44,0xa9,0x00,0xd2,0x3d,0x6b,0xbe,0xfa,0x0a,0xf6,0x19,0xaf,0xa9,0xf6,0xb7,0x2a,0x80,0x4e,0xe3,0xe1,0x6a,0xb7,0x3f,0xf5,0x83,0x2b,0x2f,0x20,0x9e,0x13,0x68,0x56,0x9d,0x35,0xdd,0x94,0xc2,0x35,0xbd,0x0d,0xb6,0x6b,0x17,0xbb,0xc0,0x69,0x4a,0xf3,0x8d,0xb7,0xc1,0x46,0x9e,0x43,0x1a,0xef,0xc9,0xea,0x1b,0x55,0xe3,0x6a,0x6a,0xbc,0x22,0x6b,0x2e,0x48,0x0f,0xd3,0xd8,0x28,0x33,0x96,0x0a,0x0b,0xdf,0x68,0x1d,0x00,0xbc,0x86,0xf3,0x3a,0xcf,0x4f,0xf2,0xf4,0x31,0xee,0x53,0xf8,0x7a,0x82,0xe6,0x0c,0x92,0xd4,0xd3,0xe2,0xbb,0xf8,0x3e,0xbb,0x3f,0xdb,0x78,0x4c,0x6d,0x50,0x9a,0x6d,0x1c,0xa3,0x3e,0x91,0xed,0xfc,0x13,0xeb,0x3f,0x81,0x4e,0x08,0xbe,0x76,0x13,0x40,0xad,0x97,0xf1,0xb8,0xb7,0x5d,0x27,0x9e,0x47,0x36,0x47,0xcf,0xa3,0xa6,0xbe,0xcc,0x57,0x3c,0x3d,0x22,0x33,0x11,0x07,0x6d,0xb4,0x69,0x05,0xe1,0x23,0xa8,0x93,0x3b,0xcd,0x8b,0x52,0x21,0x75,0x2c,0x60,0x91,0x22,0x07,0x30,0x17,0xc1,0x01,0xa2,0x69,0x1c,0x54,0x23,0xd8,0x96,0xae,0x1d,0xa9,0x2d,0x1a,0x29,0xdd,0x99,0x69,0x5e,0xc2,0xb9,0xe9,0x92,0x61,0x8a,0x41,0x0d,0x07,0xf3,0xb5,0x71,0x6a,0xb9,0xee,0x46,0xed,0x1a,0x07,0xa5,0x8a,0x14,0x93,0x8c,0x2b,0x1c,0x94,0x30,0x2c,0x65,0x1c,0xd0,0x0c,0x6f,0x88,0x43,0x6f,0x79,0xb5,0xd2,0x60,0xf9,0x96,0x3b,0x40,0x52,0x24,0x71,0x10,0x34,0x2a,0x56,0x16,0x01,0x09,0x56,0xa7,0xa8,0x52,0xca,0x7e,0x37,0xd2,0xfb,0xe0,0xed,0xa4,0xce,0x33,0xc1,0xa2,0x03,0x64,0x3f,0xdc,0xa1,0x4c,0x04,0x2d,0x54,0xb3,0x08,0x40,0xa5,0x42,0xba,0x92,0xa3,0x18,0xa5,0x3c,0x29,0x33,0x28,0x30,0xe1,0x86,0xa8,0x0f,0x8c,0xe8,0xe1,0xfb,0xe3,0x6d,0x3a,0x68,0x54,0xb7,0xe9,0xad,0xe2,0xfa,0x7c,0xb7,0xfc,0xd7,0xef,0x1f,0x81,0x2f,0xd8,0xcb,0x59,0x14,0x05,0xe8,0x17,0xf0,0x9f,0x3c,0xe5,0xfb,0x10,0x9c,0x0a,0xeb,0xac,0x14,0x6e,0x39,0xac,0xfb,0x05,0x05,0xb3,0xb7,0xd3,0xc0,0x67,0xde,0x4b,0x60,0xcc,0x41,0xec,0x67,0xb2,0xba,0x03,0x1f,0x24,0x6a,0x50,0xe1,0x81,0x90,0x7a,0xe1,0x5e,0x86,0x3c,0xcf,0x88,0x94,0x60,0x5c,0x58,0x3c,0xa8,0x87,0x43,0x14,0x2f,0x1c,0x57,0xa6,0x6b,0x3b,0x13,0xa6,0x58,0x61,0xe8,0x30,0x20,0x8e,0xf2,0x84,0xf0,0x35,0x7a,0xcf,0xf8,0x6a,0xe8,0xac,0x45,0x68,0x87,0x05,0x2a,0x05,0xfb,0xcd,0xa4,0x38,0x00,0x05,0x81,0x61,0x02,0x9b,0x53,0xa4,0x22,0xc1,0xb7,0x87,0xe6,0xd4,0x1c,0x60,0x06,0x33,0x85,0x70,0x7c,0xc0,0x67,0x31,0xda,0xf9,0x26,0xe0,0x7e,0xd8,0x0d,0x68,0x61,0xa9,0xc0,0x9b,0x5b,0x5d,0x4b,0x1d,0xf3,0xfe,0xb7,0x24,0xe2,0x78,0x67,0xaa,0x10,0x17,0x83,0xc0,0x14,0x89,0xd6,0xb8,0x9a,0xab,0xed,0x5b,0x1e,0x61,0x6b,0x1d,0xa2,0x9f,0xf7,0xb3,0x0e,0x66,0x00,0xb0,0x84,0x90,0xaf,0xd7,0x92,0xa8,0x8a,0x3e,0x46,0x5a,0x6c,0x87,0x34,0xb5,0xe9,0xc3,0x43,0xfa,0xd5,0x04,0x46,0x0f,0x54,0x3d,0xe1,0x61,0x59,0x9a,0x0f,0x96,0xe1,0xc3,0x0d,0xd8,0xe2,0x57,0x2e,0xe8,0xff,0x34,0x0a,0x73,0xe1,0x2a,0xf9,0x11,0x9a,0xf6,0x70,0xfc,0x41,0x84,0xa2,0xd0,0x15,0xba,0xeb,0x6b,0x19,0x86,0xe1,0x94,0x03,0xc5,0x4e,0x26,0xea,0x4a,0x5d,0x74,0x71,0x9d,0x03,0x7e,0xf7,0xc8,0xdc,0xec,0x14,0xcb,0xca,0x3e,0x1b,0x38,0x26,0x2d,0x0d,0xc3,0x1d,0x66,0x25,0xb8,0xb0,0x45,0xab,0x3a,0xe4,0x19,0x82,0x90,0x79,0x44,0xd3,0x76,0x2e,0xb0,0x39,0xb8,0x87,0xc3,0xda,0xc7,0x5d,0x0f,0x73,0xbd,0x8b,0x5d,0xfb,0xd6,0x5d,0x4e,0x8c,0xd6,0x98,0x49,0xdb,0x09,0x99,0x83,0x2f,0x85,0x80,0x3d,0x7c,0xe9,0xa1,0x3d,0xb8,0xb4,0xba,0x99,0xf7,0xd6,0xd5,0x34,0x6f,0xdd,0xe1,0x37,0xe3,0x19,0x20,0xca,0x73,0x89,0x63,0x3f,0x19,0x72,0xaa,0xba,0x87,0xec,0x3e,0x32,0xa3,0x3b,0x28,0x6b,0x23,0x24,0xe1,0xff,0x9e,0x66,0x04,0x12,0xf9,0xa9,0xd5,0xa1,0x17,0xf8,0xb0,0x83,0xc1,0x47,0x2a,0xa1,0x4b,0x26,0x10,0x1b,0xa6,0x07,0x34,0xe5,0x34,0x18,0x99,0x10,0xbc,0xd3,0xe3,0x51,0xb5,0x53,0x1b,0x2d,0x4f,0x01,0x80,0xcc,0x9a,0xfd,0x83,0xd6,0xe1,0x79,0xcc,0x19,0x34,0x7d,0x35,0xf7,0x33,0x58,0x33,0x0e,0x2d,0x2a,0xa4,0xd0,0xfc,0x85,0x7a,0x1b,0xfe,0xb2,0x78,0x91,0xda,0x86,0xb7,0x57,0xed,0xa6,0x95,0x28,0x73,0xd3,0x55,0xb7,0x9a,0x0d,0x20,0x1b,0xfb,0xa9,0x98,0x84,0x40,0x87,0x30,0x40,0x71,0x0c,0xa9,0xab,0x4e,0x7e,0x7e,0x0e,0xb6,0x7e,0xa7,0x44,0xe9,0xf4,0xe6,0x96,0x1f,0xca,0xbb,0xe1,0x76,0x4f,0xd1,0x47,0xb0,0xd7,0xc8,0x2f,0x80,0x02,0x1c,0xe6,0xb0,0xe4,0xbf,0x27,0xff,0x09,0x13,0x46,0x5d,0xc7,0xf5,0x16,0x3f,0xf4,0x2f,0xb6,0x9e,0x6a,0x92,0x37,0x22,0xb0,0xe5,0xc7,0x84,0x3d,0x2d,0xa1,0x0f,0xf6,0xb4,0x4a,0xf4,0x1a,0x15,0x0e,0xcc,0x37,0x69,0x13,0x89,0x6e,0x8c,0x58,0xaa,0x16,0x07,0x54,0x4b,0x86,0x58,0xba,0x17,0x38,0x97,0x0c,0xca,0xd9,0xa0,0xe1,0x1c,0xd9,0xd5,0xd5,0xa9,0x9a,0xf3,0x70,0x98,0x9e,0x9b,0xbb,0x20,0xbb,0x7c,0x31,0xa9,0xa5,0xd5,0x0d,0x0a,0x3c,0x7a,0xf0,0x68,0xb0,0xf9,0xf6,0x82,0xdb,0x9b,0x66,0xfa,0xf7,0x7f,0xea,0x4f,0x15,0xb7,0x7f,0xfc,0x24,0x2c,0x04,0xd1,0xbe,0x7b,0x43,0xd6,0xb8,0x64,0x6a,0xe0,0x55,0xe9,0x5e,0x2f,0x32,0x6e,0xdd,0x75,0x22,0xc7,0xb8,0x7d,0x4e,0xa4,0xcb,0x5a,0x27,0xc1,0x9d,0x98,0xbf,0xcf,0x9f,0x5a,0xbe,0xa7,0x5d,0xcb,0x53,0xe1,0x59,0x72,0x9f,0x10,0xd6,0xda,0xbf,0xb2,0xc8,0x27,0xac,0xb6,0x21,0x5e,0x49,0xeb,0x17,0xc3,0xb6,0x12,0x0e,0xcf,0xa9,0x64,0x87,0x0b,0x34,0x69,0x8b,0x23,0x94,0x42,0xb8,0x90,0x78,0xe5,0xe4,0x9c,0x94,0x07,0x47,0x4a,0x53,0xa7,0x7a,0xa5,0xe9,0x3d,0xd9,0xe1,0x79,0x69,0x0e,0xeb,0x8b,0x9c,0xfd,0x25,0xee,0xde,0xe3,0xf0,0x91,0x55,0xae,0xc7,0xf5,0xdb,0xd9,0x9e,0xde,0xb0,0x51,0x25,0x8a,0x10,0xa3,0x19,0x55,0xa6,0xb0,0xc1,0x45,0x16,0x6e,0xe7,0x48,0x3f,0x6b,0x35,0xed,0x2e,0xb8,0xb7,0x38,0xa2,0x8f,0xb7,0x9f,0x6e,0xef,0x97,0x9f,0xee,0x50,0x26,0x5b,0xbe,0xad,0x52,0x85,0xee,0xb7,0x37,0x54,0x6d,0xcb,0x55,0x98,0xf0,0x2c,0xca,0x09,0xcf,0x29,0x64,0xef,0x08,0x5e,0x82,0xbe,0xca,0x25,0x91,0xc5,0xe5,0x74,0x49,0x0e,0x38,0x2b,0x18,0x91,0x11,0xdc,0xf1,0x56,0x51,0x06,0xa5,0x94,0x08,0xbb,0x72,0x09,0xc2,0xa2,0x84,0x30,0x56,0x6c,0x61,0xb4,0xd4,0x8d,0x95,0x79,0x4d,0x4b,0x97,0x22,0x59,0x26,0x58,0x44,0xfb,0xfd,0x3e,0x82,0x66,0x9e,0x1c,0x42,0xfd,0x16,0xe8,0x54,0x67,0xab,0x53,0x8c,0x2e,0xae,0xda,0xec,0x63,0xc3,0x58,0x6f,0x68,0xa0,0x0e,0xca,0x0d,0x36,0xcd,0x97,0x73,0x7d,0xc5,0xd0,0x1d,0xff,0x8d,0x3e,0xb1,0xa1,0x3e,0x00,0x5d,0xd1,0xdd,0xe0,0xd5,0x2e,0xd4,0xd4,0x7c,0x13,0xbc,0x70,0x05,0x24,0x6b,0x68,0xf8,0x52,0xf4,0xfd,0xbb,0x41,0x18,0xdb,0x9e,0x00,0x2d,0x62,0xab,0x8b,0x1f,0xd8,0x0a,0x2c,0xe7,0x47,0x19,0xdc,0x24,0xac,0x5a,0x7e,0x48,0xb5,0xd2,0x9e,0x50,0xcd,0xbc,0xa9,0x10,0x55,0x0a,0xe7,0x2d,0x44,0xc7,0x34,0x5c,0x74,0x92,0x2d,0x24,0x9c,0x93,0xdc,0x02,0xb7,0x1c,0xce,0x08,0x5c,0x85,0x74,0x52,0x7b,0xbc,0x16,0x54,0x6a,0xe8,0x96,0x47,0x17,0xc5,0x83,0x73,0xa7,0xd0,0x06,0xf9,0xc9,0xe9,0x7d,0x4e,0x2f,0x33,0x19,0xdc,0xa3,0xfa,0x77,0xf4,0x93,0x67,0xbf,0x77,0xed,0xc1,0x8d,0xd1,0xc0,0x37,0xe5,0x10,0x62,0xac,0x99,0xed,0x46,0x34,0xe0,0xcf,0xd1,0x64,0x68,0xe4,0xb8,0x25,0x48,0x07,0xa0,0x55,0x0b,0xa6,0x74,0x38,0x56,0x1f,0x83,0x41,0xe7,0x86,0x76,0xba,0x38,0x2f,0x19,0x34,0xcf,0xdd,0x79,0x73,0xf4,0xda,0x0a,0xbe,0xb9,0x46,0x20,0xdb,0xa1,0x9c,0x2f,0xa0,0x5e,0x46,0x38,0xfc,0x93,0xcb,0x11,0x3a,0x9a,0x7f,0xc2,0x5c,0xbb,0x11,0x16,0x9a,0xfb,0x7e,0xa8,0xf4,0x62,0x78,0x10,0xd2,0x77,0xb3,0xc0,0x7c,0x68,0xce,0x4b,0xc8,0x05,0x10,0xcd,0x9a,0x5f,0x47,0x77,0x71,0x18,0x99,0xe8,0xd6,0x48,0xcd,0xf7,0x64,0x68,0x2f,0xb3,0xd5,0x21,0x14,0x38,0xbf,0x21,0x1b,0x41,0x88,0x36,0x92,0x11,0x8d,0xfe,0xaa,0x1f,0x45,0x87,0x7d,0xb9,0x40,0x33,0x28,0xca,0xa0,0x78,0x59,0x0e,0x03,0x7e,0x9e,0xc3,0x18,0xc7,0x91,0x01,0x6a,0x8c,0xb4,0x4e,0x0e,0x4a,0xe7,0xe5,0x11,0xde,0x58,0xec,0x35,0x7f,0x1e,0xe9,0xb7,0x95,0xc5,0x2b,0x78,0x6c,0x31,0xaf,0xfa,0x7f,0x02,0xa4,0xc9,0x43,0x04,0xdd,0x17,0x00,0x00
};
 
#define PWDN_GPIO_NUM     32
#define RESET_GPIO_NUM    -1
#define XCLK_GPIO_NUM      0
#define SIOD_GPIO_NUM     26
#define SIOC_GPIO_NUM     27
#define Y9_GPIO_NUM       35
#define Y8_GPIO_NUM       34
#define Y7_GPIO_NUM       39
#define Y6_GPIO_NUM       36
#define Y5_GPIO_NUM       21
#define Y4_GPIO_NUM       19
#define Y3_GPIO_NUM       18
#define Y2_GPIO_NUM        5
#define VSYNC_GPIO_NUM    25
#define HREF_GPIO_NUM     23
#define PCLK_GPIO_NUM     22
 
camera_fb_t * fb = NULL;
 
using namespace websockets;
WebsocketsServer server;
AsyncWebServer webserver(80);
 
const int fwdPin = 2;  //Forward Motor Pin
const int turnPin = 12;  //Steering Servo Pin
 
// Arduino like analogWrite
// value has to be between 0 and valueMax
void fwdAnalogWrite(uint8_t channel, uint32_t value, uint32_t valueMax = 4000) {
  // calculate duty, 8191 from 2 ^ 13 - 1
  uint32_t duty = (8191 / valueMax) * min(value, valueMax);
  ledcWrite(channel, duty);
}
void steeringAnalogWrite(uint8_t channel, uint32_t value, uint32_t valueMax = 180) {
  // calculate duty, 8191 from 2 ^ 13 - 1
  uint32_t duty = (8191 / valueMax) * min(value, valueMax);
  ledcWrite(channel, duty);
}
 
void setup()
{
  Serial.begin(115200);
 
  // forward motor PWM
  ledcSetup(2, 200, 12); //channel, freq, resolution
  ledcAttachPin(fwdPin, 2); // pin, channel
 
  // steering servo PWM
  ledcSetup(4, 50, 16); //channel, freq, resolution
  ledcAttachPin(turnPin, 4); // pin, channel
 
  camera_config_t config;
  config.ledc_channel = LEDC_CHANNEL_0;
  config.ledc_timer = LEDC_TIMER_0;
  config.pin_d0 = Y2_GPIO_NUM;
  config.pin_d1 = Y3_GPIO_NUM;
  config.pin_d2 = Y4_GPIO_NUM;
  config.pin_d3 = Y5_GPIO_NUM;
  config.pin_d4 = Y6_GPIO_NUM;
  config.pin_d5 = Y7_GPIO_NUM;
  config.pin_d6 = Y8_GPIO_NUM;
  config.pin_d7 = Y9_GPIO_NUM;
  config.pin_xclk = XCLK_GPIO_NUM;
  config.pin_pclk = PCLK_GPIO_NUM;
  config.pin_vsync = VSYNC_GPIO_NUM;
  config.pin_href = HREF_GPIO_NUM;
  config.pin_sscb_sda = SIOD_GPIO_NUM;
  config.pin_sscb_scl = SIOC_GPIO_NUM;
  config.pin_pwdn = PWDN_GPIO_NUM;
  config.pin_reset = RESET_GPIO_NUM;
  config.xclk_freq_hz = 20000000;
  config.pixel_format = PIXFORMAT_JPEG;
  //init with high specs to pre-allocate larger buffers
  if (psramFound()) {
    config.frame_size = FRAMESIZE_UXGA;
    config.jpeg_quality = 10;
    config.fb_count = 2;
  } else {
    config.frame_size = FRAMESIZE_SVGA;
    config.jpeg_quality = 12;
    config.fb_count = 1;
  }
   
  // camera init
  esp_err_t err = esp_camera_init(&config);
  if (err != ESP_OK) {
    Serial.printf("Camera init failed with error 0x%x", err);
    return;
  }
 
  sensor_t * s = esp_camera_sensor_get();
  s->set_framesize(s, FRAMESIZE_SVGA);
 
  // Connect to wifi
  WiFi.begin(ssid, password);
 
  // Wait some time to connect to wifi
  for (int i = 0; i < 15 && WiFi.status() != WL_CONNECTED; i++) {
    Serial.print(".");
    delay(1000);
  }
 
  Serial.println("");
  Serial.println("WiFi connected");
  Serial.println("IP address: ");
  Serial.println(WiFi.localIP());   // You can get IP address assigned to ESP
 
  webserver.on("/", HTTP_GET, [](AsyncWebServerRequest * request) {
    AsyncWebServerResponse *response = request->beginResponse_P(200, "text/html", index_html_gz, sizeof(index_html_gz));
    response->addHeader("Content-Encoding", "gzip");
    request->send(response);
  });
 
  webserver.begin();
  server.listen(82);
  Serial.print("Is server live? ");
  Serial.println(server.available());
 
}
 
void handle_message(WebsocketsMessage msg) {
  int commaIndex = msg.data().indexOf(',');
  int steerValue = msg.data().substring(0, commaIndex).toInt();
  int forwardValue = msg.data().substring(commaIndex + 1).toInt();

  Serial.print(" t: ");
  Serial.print(millis());
  Serial.print(" |  Received -> steer : ");
  Serial.print(steerValue );
  Serial.print("   fw :  ");
  Serial.print(forwardValue );
  Serial.println(" ");
/* 
  if (steerValue > 5 ) {
    steeringAnalogWrite(4, 112);
  }
  else if (steerValue < -5 ) {
    steeringAnalogWrite(4, 65);
  }
  else {
    steeringAnalogWrite(4, 85); // center steering
  }
 
  forwardValue = map(forwardValue, 0, -90, 500, 2000);
 
  if (forwardValue > 600 ) {
    fwdAnalogWrite(2, forwardValue);
  }
  else {
    fwdAnalogWrite(2, 0); // stop
  }
  */
}
 
void loop()
{
  auto client = server.accept();
  client.onMessage(handle_message);
  while (client.available()) {
    client.poll();
        fb = esp_camera_fb_get();
        client.sendBinary((const char *)fb->buf, fb->len);
        esp_camera_fb_return(fb);
        fb = NULL;
  }
 
}
